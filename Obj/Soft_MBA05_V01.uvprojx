# Keil uVision project Soft_MBA05_V01.uvprojx, settings and files
target MB_A05_V01 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Soft_MBA05_V01 +hex
  AfterMake: fromelf.exe --bin --output @L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: AT32F435RGT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1,HEXT_VALUE=24000000
  c include: ..\API\inc;..\BSP\inc;..\Driver\inc;..\Core\core_support;..\Core\device_support;..\Hal\inc;..\APP;..\freertos\source\include;..\freertos\source\portable\memmang;..\freertos\source\portable\rvds\ARM_CM4F;..\freertos;..\freertos\at32f435\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfb000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group API
    ../API/src/: api_common.c api_fifo.c
    ../APP/: main.c
  group Core
    ../Core/device_support/: system_at32f435_437.c
    ../Core/device_support/startup/mdk/: startup_at32f435_437.s
  group Driver
    ../Driver/src/: at32f435_437_adc.c at32f435_437_crm.c at32f435_437_dma.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_pwc.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_scfg.c at32f435_437_wwdt.c
  group HAL
    ../Hal/src/: Hal_KeyLed.c Hal_Init.c Hal_PowManage.c Hal_Uart.c Hal_Sleep.c Hal_Flash.c
  group BSP
    ../BSP/src/: Bsp_KeyLed.c Bsp_UartRec.c Bsp_BatVol.c Bsp_Init.c Bsp_GnssParse.c Bsp_RdssParse.c Bsp_RdssSend.c Bsp_Log.c Bsp_Config.c Bsp_Task.c
  group APP
    ../APP/: Sys_TimeRun.c
  group FreeRtos
    ../freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/source/portable/memmang/: heap_4.c
    ../freertos/: FreeRTOSConfig.h
  group DEMO
    ../freertos/at32f435/src/: at32f435_437_int.c include_port.c
